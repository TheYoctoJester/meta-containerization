SUMMARY = "A small container just able to run bash"

IMAGE_INSTALL = "bash"
IMAGE_LINGUAS = " "

LICENSE = "MIT"

inherit image
inherit image-container
