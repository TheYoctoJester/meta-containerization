SUMMARY = "A small image just able to run busybox"

IMAGE_INSTALL = "busybox"
IMAGE_LINGUAS = " "

LICENSE = "MIT"

inherit image
inherit image-container
