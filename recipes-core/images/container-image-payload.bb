SUMMARY = "A small container just packing up the PAYLOAD"

IMAGE_INSTALL = "${PAYLOAD}"
IMAGE_LINGUAS = ""

LICENSE = "MIT"

inherit image
inherit image-container
